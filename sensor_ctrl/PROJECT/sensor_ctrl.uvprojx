# Keil uVision project sensor_ctrl.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sensor_ctrl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\HARDWARE\delay;..\HARDWARE\usart;..\HARDWARE\encoder;..\HARDWARE\motor;..\HARDWARE\timer;..\HARDWARE\ultrasonic;..\HARDWARE\sys_time;..\HARDWARE\tracking;..\HARDWARE\mpu6050;..\HARDWARE\buzzer;..\HARDWARE\key;..\HARDWARE\led;..\HARDWARE\adc_battery;..\HARDWARE\w25q64;..\HARDWARE\debug_usart;..\HARDWARE\servo_bus;..\HARDWARE\path_planner;..\HARDWARE\ik_solver;..\HARDWARE\protocol;..\SYS\delay;..\SYS\sys;..\FreeRTOS\include;..\FreeRTOS\portable;..\APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_spi.c
  group USER
    ../USER/: stm32f4xx_it.c system_stm32f4xx.c main.c
  group HARDWARE
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/ultrasonic/: ultrasonic.c
    ../HARDWARE/sys_time/: sys_time.c
    ../HARDWARE/tracking/: tracking.c
    ../HARDWARE/mpu6050/: mpu6050.c
    ../HARDWARE/buzzer/: buzzer.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/adc_battery/: adc_battery.c
    ../HARDWARE/w25q64/: w25q64.c
    ../HARDWARE/debug_usart/: debug_usart.c
    ../HARDWARE/servo_bus/: servo_bus.c
    ../HARDWARE/path_planner/: path_planner.c
    ../HARDWARE/ik_solver/: ik_solver.c
    ../HARDWARE/protocol/: protocol.c
  group SYS
    ../SYS/delay/: delay.c
    ../SYS/sys/: sys.c
  group FreeRTOS
    ../FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/: heap_4.c port.c
